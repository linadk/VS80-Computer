File: kicad/V80.sch (KiCad schematic (older format))
At the start: 0 parts

Commit message: Commit all work
Other:
- note added: "Clock Bus"
- note added: "Primary Data Bus"
